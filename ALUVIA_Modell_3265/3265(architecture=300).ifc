Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_576/temp/tmp_1656_25_AjPOn/format_0/3265(architecture=300).ifc
Time: 2025-09-01T09:05:06
Made in: PARTsolutions

# IfcProject, 3265(architecture=300)
Description: ALUVIA

# IfcDiscreteAccessory, 3265(architecture=300)
In: BUILDING
Description: 3265(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 3265
ePset_PARTsolutions - NB: 3265(architecture=300); NN: 3265; NT: ALUVIA; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 3265(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 3265; B: 3265_aluvia_900x1600.png; C: ALUVIA; E: KALDEWEI; EF000049: 900; EF004567: 1600; etim7_EC003246: EC003246; etim7_EC003246_WIDTH: 1600; etim7_EC003246_LENGTH: 900
